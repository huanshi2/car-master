# Keil uVision project Car.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Car +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.3.0\Device\StdPeriph_Driver\inc;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.3.0\Device\StdPeriph_Driver\templates;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.3.0\Device\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.3.0\RTE_Driver;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\2.3.0\Boards\Keil\MCBSTM32C\Middleware\Network\BSD_Server\RTE;..\User;..\dmp_library;..\vl51\core\inc;..\vl51\core\src;..\vl51\platform\inc;..\vl51\platform\src;..\vl51\demo;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../System/: startup_stm32f10x_hd.s
  group USER
    ../User/: main.c ec_led.c ec_motor.c ec_timer.c ec_key.c ec_usart.c ec_delay.c system_stm32f10x.c stm32f10x_it.c stm32f10x_i2c.c sys.c stmflash.c stack.c control.c
  group Libraries
    ../Libraries/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c
    ../User/: stm32f10x_exti.c
  group dmp
    ../User/: inv_mpu.c inv_mpu_dmp_motion_driver.c IOI2C.c MPU6050.c exti.c
  group vl51
    ../vl51/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../vl51/platform/src/: vl53l0x_i2c.c vl53l0x_platform.c
    ../vl51/demo/: vl53l0x.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_it.c
